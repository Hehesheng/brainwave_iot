# Keil uVision project project.uvprojx, settings and files
target rt-thread (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F429IGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.14.0
  cpu: IRAM(0x20000000,0x30000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: rt-thread
  AfterMake: fromelf --bin !L --output rtthread.bin
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER, RT_USING_ARM_LIBC, STM32F429xx
  c include: .;rt-thread/include;applications;.;board;board/CubeMX_Config/Inc;board/ports;libraries/HAL_Drivers;libraries/HAL_Drivers/config;packages/cJSON;packages/cJSON/inc;packages/CmBacktrace-v1.2.2;packages/dstr-latest/inc;packages/onenet-latest/inc;packages/optparse-v1.0.0;packages/pahomqtt-latest/MQTTPacket/src;packages/pahomqtt-latest/MQTTClient-RT;packages/rw007-latest;packages/rw007-latest/inc;packages/SystemView-latest;packages/SystemView-latest/SystemView_Src/Config;packages/SystemView-latest;packages/SystemView-latest/SystemView_Src/SEGGER;packages/webclient-v2.0.1/inc;rt-thread/libcpu/arm/common;rt-thread/libcpu/arm/cortex-m4;rt-thread/components/dfs/include;rt-thread/components/dfs/filesystems/devfs;rt-thread/components/dfs/filesystems/elmfat;rt-thread/components/drivers/include;rt-thread/components/drivers/include;rt-thread/components/drivers/include;rt-thread/components/drivers/include;rt-thread/components/drivers/include;rt-thread/components/drivers/spi;rt-thread/components/drivers/include;rt-thread/components/drivers/spi/sfud/inc;rt-thread/components/drivers/include;rt-thread/components/drivers/wlan;rt-thread/components/finsh;rt-thread/components/libc/compilers/armlibc;rt-thread/components/libc/compilers/common;rt-thread/components/net/lwip-2.0.2/src;rt-thread/components/net/lwip-2.0.2/src/include;rt-thread/components/net/lwip-2.0.2/src/include/ipv4;rt-thread/components/net/lwip-2.0.2/src/arch/include;rt-thread/components/net/lwip-2.0.2/src/include/netif;rt-thread/components/net/netdev/include;rt-thread/components/net/sal_socket/include;rt-thread/components/net/sal_socket/include/socket;rt-thread/components/net/sal_socket/impl;rt-thread/components/net/sal_socket/include/dfs_net;rt-thread/components/net/sal_socket/include/dfs_net/sys_select;rt-thread/components/net/sal_socket/include/socket/sys_socket;rt-thread/components/utilities/ulog;libraries/STM32F4xx_HAL/STM32F4xx_HAL_Driver/Inc;libraries/STM32F4xx_HAL/CMSIS/Device/ST/STM32F4xx/Include;libraries/STM32F4xx_HAL/CMSIS/Include
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  scatter file: .\board\linker_scripts\link.sct
  group Kernel
    rt-thread/src/: clock.c components.c cpu.c device.c idle.c ipc.c irq.c kservice.c memheap.c mempool.c object.c scheduler.c signal.c thread.c timer.c
  group Applications
    applications/: app_ad5933.c drv_ad5933.c hmi.c main.c onenet_service.c tgam.c upload.c wifi.c
  group Drivers
    board/: board.c
    board/CubeMX_Config/Src/: stm32f4xx_hal_msp.c
    board/ports/: spi_flash_init.c sdcard_port.c
    libraries/STM32F4xx_HAL/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f429xx.s
    libraries/HAL_Drivers/: drv_gpio.c drv_usart.c drv_spi.c drv_soft_i2c.c drv_sdram.c drv_sdio.c drv_common.c
  group cJSON
    packages/cJSON/: cJSON_Utils.c cJSON.c cJSON_port.c
  group cm_backtrace
    packages/CmBacktrace-v1.2.2/: cm_backtrace.c cmb_port.c
  group dstr
    packages/dstr-latest/src/: dstr.c
  group onenet
    packages/onenet-latest/src/: onenet_http.c onenet_mqtt.c
  group optparse
    packages/optparse-v1.0.0/: optparse.c
  group paho-mqtt
    packages/pahomqtt-latest/MQTTPacket/src/: MQTTConnectClient.c MQTTConnectServer.c MQTTDeserializePublish.c MQTTFormat.c MQTTPacket.c MQTTSerializePublish.c MQTTSubscribeClient.c MQTTSubscribeServer.c MQTTUnsubscribeClient.c MQTTUnsubscribeServer.c
    packages/pahomqtt-latest/MQTTClient-RT/: paho_mqtt_pipe.c
  group rw007
    packages/rw007-latest/src/: spi_wifi_rw007.c
    packages/rw007-latest/example/: rw007_stm32_port.c
  group trace
    packages/SystemView-latest/SystemView_Src/Config/: SEGGER_RTT_Device.c SEGGER_SYSVIEW_Config_RTThread.c SEGGER_SYSVIEW_RTThread.c
    packages/SystemView-latest/SystemView_Src/SEGGER/: SEGGER_RTT.c SEGGER_SYSVIEW.c
  group WebClient
    packages/webclient-v2.0.1/src/: webclient.c webclient_file.c
  group cpu
    rt-thread/libcpu/arm/common/: backtrace.c div0.c showmem.c
    rt-thread/libcpu/arm/cortex-m4/: cpuport.c context_rvds.S
  group Filesystem
    rt-thread/components/dfs/src/: dfs.c dfs_file.c dfs_fs.c dfs_posix.c poll.c select.c
    rt-thread/components/dfs/filesystems/devfs/: devfs.c
    rt-thread/components/dfs/filesystems/elmfat/: dfs_elm.c ff.c
    rt-thread/components/dfs/filesystems/elmfat/option/: ccsbcs.c
  group DeviceDrivers
    rt-thread/components/drivers/i2c/: i2c_core.c i2c_dev.c i2c-bit-ops.c
    rt-thread/components/drivers/misc/: pin.c
    rt-thread/components/drivers/rtc/: rtc.c
    rt-thread/components/drivers/sdio/: block_dev.c mmcsd_core.c sd.c sdio.c mmc.c
    rt-thread/components/drivers/serial/: serial.c
    rt-thread/components/drivers/spi/: spi_core.c spi_dev.c spi_flash_sfud.c
    rt-thread/components/drivers/spi/sfud/src/: sfud.c sfud_sfdp.c
    rt-thread/components/drivers/src/: completion.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    rt-thread/components/drivers/wlan/: wlan_cfg.c wlan_cmd.c wlan_dev.c wlan_lwip.c wlan_mgnt.c wlan_prot.c wlan_workqueue.c
  group finsh
    rt-thread/components/finsh/: shell.c symbol.c cmd.c msh.c msh_cmd.c msh_file.c
  group libc
    rt-thread/components/libc/compilers/armlibc/: libc.c libc_syms.c mem_std.c stdio.c stubs.c time.c
    rt-thread/components/libc/compilers/common/: gmtime_r.c
  group lwIP
    rt-thread/components/net/lwip-2.0.2/src/arch/: sys_arch.c
    rt-thread/components/net/lwip-2.0.2/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
    rt-thread/components/net/lwip-2.0.2/src/core/: def.c dns.c inet_chksum.c init.c ip.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
    rt-thread/components/net/lwip-2.0.2/src/netif/: ethernet.c ethernetif.c lowpan6.c
    rt-thread/components/net/lwip-2.0.2/src/core/ipv4/: autoip.c dhcp.c etharp.c icmp.c igmp.c ip4.c ip4_addr.c ip4_frag.c
    rt-thread/components/net/lwip-2.0.2/src/apps/ping/: ping.c
  group netdev
    rt-thread/components/net/netdev/src/: netdev.c netdev_ipaddr.c
  group SAL
    rt-thread/components/net/sal_socket/src/: sal_socket.c
    rt-thread/components/net/sal_socket/socket/: net_netdb.c net_sockets.c
    rt-thread/components/net/sal_socket/impl/: af_inet_lwip.c
    rt-thread/components/net/sal_socket/dfs_net/: dfs_net.c
  group Utilities
    rt-thread/components/utilities/ulog/: ulog.c
    rt-thread/components/utilities/ulog/backend/: console_be.c
  group STM32_HAL
    libraries/STM32F4xx_HAL/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
    libraries/STM32F4xx_HAL/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_cec.c stm32f4xx_hal_cortex.c stm32f4xx_hal_crc.c stm32f4xx_hal_cryp.c stm32f4xx_hal_cryp_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_rng.c stm32f4xx_hal_gpio.c stm32f4xx_hal_uart.c stm32f4xx_hal_usart.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_spi.c stm32f4xx_hal_qspi.c stm32f4xx_hal_rtc.c stm32f4xx_hal_rtc_ex.c stm32f4xx_ll_sdmmc.c stm32f4xx_hal_sd.c stm32f4xx_ll_fmc.c stm32f4xx_ll_fsmc.c stm32f4xx_hal_sdram.c
